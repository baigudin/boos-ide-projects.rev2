# Keil uVision project boos.exe.siliconlabs.c8051f902.uvproj, settings and files
target boos.exe.siliconlabs.c8051f902 (MCS-51)
  device: C8051F902 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x0200) IROM(0-0x2000) CLOCK(25000000)
  output: boos.exe.siliconlabs.c8051f902
  c flags: Optimize=8 SizeSpeed=1
  c define: BOOS_TYPE_C_STANDARD,BOOS_VENDOR_BOOT
  c include: ..\..\..\boos\include
  group source
    ../../../boos/system/: boos.system.main.c
    ../../../boos/driver/siliconlabs/c8051f90x/: boos.driver.processor.c boos.driver.interrupt.c boos.driver.watchdog.c boos.driver.pll.c boos.driver.timer.c boos.driver.interrupt.ll.asm boos.driver.boot.ll.asm
    ../source/: boos.main.c
