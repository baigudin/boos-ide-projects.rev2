# Keil uVision project rczi.icb.009.uvproj, settings and files
target rczi.icb.009 (MCS-51)
  device: C8051F902 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x0200) IROM(0-0x2000) CLOCK(25000000)
  output: rczi.icb.009 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: BOOS_TYPE_C_STANDARD
  c include: ..\..\..\boos-core-microbe\boos\include
  group source
    ../source/: Board.c driver.Ksz.c driver.Led.c driver.Max.c driver.Mdio.c Main.c
    ../../../boos-core-microbe/boos/system/: boos.system.Main.c boos.system.Thread.c
    ../../../boos-core-microbe/boos/driver/siliconlabs/c8051f90x/: boos.driver.Comparator.c boos.driver.Interrupt.c boos.driver.Pll.c boos.driver.Processor.c boos.driver.Timer.c boos.driver.Watchdog.c boos.driver.Boot.ll.asm boos.driver.Interrupt.ll.asm
